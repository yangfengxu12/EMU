# Keil uVision project Lora.uvprojx, settings and files
target sx1276mb1mas (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx, USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER, REGION_EU868, USE_MODEM_LORA
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic;..\..\..\..\..\..\Drivers\BSP\\Components\sx1276;..\..\..\..\..\..\Drivers\BSP\sx1276mb1mas
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sx1272/: sx1272.c
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../../../../../Drivers/BSP/Components/sx126x/: radio.c sx126x.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../Drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
  group Drivers/BSP/sx1261dvk1bas
    ../../../../../../Drivers/BSP/SX1261DVK1BAS/: sx1261dvk1bas.c
  group Drivers/BSP/sx1262dvk1cas
    ../../../../../../Drivers/BSP/SX1262DVK1CAS/: sx1262dvk1cas.c
  group Drivers/BSP/sx1262dvk1das
    ../../../../../../Drivers/BSP/SX1262DVK1DAS/: sx1262dvk1das.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart_ex.c
  group Projects/MDK-ARM
    ./: startup_stm32l476xx.s
  group Projects/PingPong
    ../LoRaWAN/App/src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c
    ../Core/src/: stm32l4xx_hal_msp.c stm32l4xx_hw.c stm32l4xx_it.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c queue.c trace.c
target sx1272mb2das (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx1272;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic;..\..\..\..\..\..\Drivers\BSP\sx1272mb2das
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target sx1276mb1las (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic;..\..\..\..\..\..\Drivers\BSP\sx1276mb1las
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target sx1261dvk1bas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx, USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER, REGION_EU868, USE_MODEM_LORA,USE_SX126X_DVK
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic;;..\..\..\..\..\..\Drivers\BSP\Components\sx126x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target sx1262dvk1cas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Patterns\Basic;..\..\..\..\..\..\Drivers\BSP\Components\sx126x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target sx1262dvk1das (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
