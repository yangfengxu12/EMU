# Keil uVision project SX1276_2_LoRa.uvprojx, settings and files
target SX1276_2_LoRa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: OOK2Chirp_Project +hex
  AfterMake: F:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L476xx, USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_LL_Driver/Inc;../Drivers/STM32L4xx_LL_Driver/Src;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\BSP;..\BSP\SX1276;..\Hardware;..\Utilities;..\Simulated_LoRa;..\LoRa_Channel_Coding;..\MALLOC;..\CB-API;..\energyest;..\Toggle\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Drivers/STM32L4xx_LL_Driver
    ../Drivers/STM32L4xx_LL_Driver/Src/: stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group BSP
    ../BSP/: stm32l4xx_nucleo.c
    ../BSP/SX1276/: sx1276.c sx1276mb1mas.c
    ../Hardware/: stm32l4xx_hw.c
  group Hardware
    ../Hardware/: debug.c vcom.c hw_gpio.c hw_rtc.c hw_spi.c timer.c sys.c fast_spi.c rtc.c delay.c usart.c control_GPIO.c
  group Utilities
    ../Utilities/: utilities.c trace.c timeServer.c queue.c low_power_manager.c
  group Sim_LoRa
    ../Simulated_LoRa/: Simulated_LoRa.c Timer_Calibration.c Simulated_LoRa.h Timer_Calibration_From_SX1276.c
  group LoRa_Channel_Coding
    ../LoRa_Channel_Coding/: LoRa_Channel_Coding.c LoRa_Channel_Coding.h Whitening.c Header.c Add_CRC.c Hanmming_Enc.c Interleaver.c Gray_decode.c Modulation.c
  group chirpobx
    ../CB-API/: API_FlashFileIO.c flash_if.c API_Log.c
    ../Toggle/Src/: ll_flash.c toggle.c
  group energyest
    ../energyest/: energest.c
software components: CMSIS:CORE 5.4.0
